# Keil uVision project TIMER_LED.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TIMER_LED
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\LIB;.\MCAL\DIO;.\MCAL\INT;.\MCAL\MCU;.\MCAL\TIMER
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group APP
    ./APP/: main.c
  group MCAL
    ./MCAL/DIO/: GPIO_config.h GPIO_interface.h GPIO_private.h GPIO_program.c
    ./MCAL/MCU/: SYSCNTRL_interface.h SYSCNTRL_private.h SYSCNTRL_program.c
  group TIM
    ./MCAL/TIMER/: TIMERS_interface.h TIMERS_private.h TIMERS_program.c
  group INT
    ./MCAL/INT/: NVIC_interface.h NVIC_program.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.1
